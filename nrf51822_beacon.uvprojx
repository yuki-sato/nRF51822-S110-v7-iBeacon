# Keil uVision project nrf51822_beacon.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_beacon
  c flags: Optim=1 wLevel=2
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99
  asm define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group source
    ./: main.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51822_xxAA/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h
  group ::nRF_Drivers
    C:/Keil/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51822_xxAA/: app_error.c app_error.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51822_xxAA/: softdevice_handler.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.0, nRF_BLE:BLE_Modules:ble_common 1.1.0, nRF_BLE:BLE_Modules:ble_conn_params 1.1.0, nRF_BLE:BLE_Modules:ble_service_common 1.1.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:nrf_assert 1.1.0, nRF_SoftDevice:Internal:sd_common 1.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.0, nRF_SoftDevice:s110 7.1.0-3
